# Keil uVision project Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1
  c define: STM32F10X_MD  USE_STDPERIPH_DRIVER
  c include: .\System;.\CORE;.\STM32F10x_FWLib\inc;.\TEXT;.\FATFS\src;.\User;.\Function
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Function
    ./Function/: timer.c echo.c IMU.c Filter.c Maths.c Tasks.c ppm.c led.c control.c i2c.c DMA_ADC.c
  group Source Group 1
    ./CORE/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group System
    ./System/: delay.c sys.c usart.c
  group CORE
    ./CORE/: core_cm3.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
